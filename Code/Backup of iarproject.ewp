# IAR project Backup of iarproject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Common; AHardware\Registers\STM32F411\FieldValues; AHardware\Registers\STM32F411; AHardware\Registers; AHardware\Registers\CortexM4; AHardware\Registers\CortexM4\FieldValues; Application\Leds; Application\Leds\Contracts; Application\Modes; Application\Modes\Contracts; Application\Leds\Config; Application\Modes\Config; Application\Button; Application\Button\Contracts; Application\ADC; Application\ADC\Contracts; Application\Timers; Application\Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Rtos; Rtos\FreeRtos; Rtos\FreeRtos\include; Rtos\FreeRtos\portable\IAR; Rtos\FreeRtos\portable\IAR\ARM_CM4F; Rtos\wrapper\FreeRtos; Rtos\wrapper
  OBJCOPY.OOCOutputFile: iarproject.srec
  ILINK.IlinkOutputFile: iarproject.out
  ILINK.IlinkIcfFile: stm32f411xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: main.cpp startupF411RE.cpp
  group AHardware/Registers
    AHardware/Registers/: accessmode.hpp fieldvalue.hpp fieldvaluebase.hpp register.hpp registerbase.hpp registerfield.hpp registertype.hpp
  group AHardware/Registers/CortexM4
    AHardware/Registers/CortexM4/: fpucpacrregisters.hpp fpuregisters.hpp mpuregisters.hpp nvicregisters.hpp nvicstirregisters.hpp scbactrlregisters.hpp scbregisters.hpp stkregisters.hpp
  group AHardware/Registers/STM32F411
    AHardware/Registers/STM32F411/: adc1registers.hpp adccommonregisters.hpp crcregisters.hpp dbgregisters.hpp dma1registers.hpp dma2registers.hpp extiregisters.hpp flashregisters.hpp gpioaregisters.hpp gpiobregisters.hpp gpiocregisters.hpp gpiodregisters.hpp gpioeregisters.hpp gpiohregisters.hpp i2c1registers.hpp i2c2registers.hpp i2c3registers.hpp i2s2extregisters.hpp i2s3extregisters.hpp iwdgregisters.hpp otgfsdeviceregisters.hpp otgfsglobalregisters.hpp otgfshostregisters.hpp otgfspwrclkregisters.hpp portslist.hpp pwrregisters.hpp rccregisters.hpp rtcregisters.hpp sdioregisters.hpp spi1registers.hpp spi2registers.hpp spi3registers.hpp spi4registers.hpp spi5registers.hpp syscfgregisters.hpp tim10registers.hpp tim11registers.hpp tim1registers.hpp tim2registers.hpp tim3registers.hpp tim4registers.hpp tim5registers.hpp tim8registers.hpp tim9registers.hpp usart1registers.hpp usart2registers.hpp usart6registers.hpp wwdgregisters.hpp
  group Application/ADC
    Application/ADC/: ADC.cpp ADC.h
  group Application/ADC/Config
    Application/ADC/Config/: ADCConfig.h
  group Application/ADC/Contracts
    Application/ADC/Contracts/: IADC.h
  group Application/Button
    Application/Button/: Button.h
    ../../8semestr/labWork/Code/Application/Button/: ButtonIsPressed.h
  group Application/Button/Contracts
    Application/Button/Contracts/: IButton.h
  group Application/Config
    Application/Config/: Config.cpp Config.h
  group Application/Leds
    Application/Leds/: Led.h
  group Application/Leds/Config
    Application/Leds/Config/: LedConfig.h
  group Application/Leds/Contracts
    Application/Leds/Contracts/: ILed.h
  group Application/Modes
    Application/Modes/: allMode.cpp allMode.h chessMode.cpp chessMode.h ModeManager.cpp ModeManager.h treeMode.cpp treeMode.h
  group Application/Modes/Config
    Application/Modes/Config/: ModesConfig.h
  group Application/Modes/Contracts
    Application/Modes/Contracts/: IMode.h IModeManager.h
  group Application/Timers
    ../../8semestr/labWork/Code/Application/Timers/: timer.h
  group Common
    Common/: utils.hpp
